FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-imx8mn-var-som-move-to-1-gib-domain.patch"
