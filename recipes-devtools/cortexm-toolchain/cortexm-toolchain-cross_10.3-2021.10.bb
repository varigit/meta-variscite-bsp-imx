require cortexm-toolchain-cross.inc

TOOLCHAIN_TARBALL = "gcc-arm-none-eabi-10.3-2021.10-x86_64-linux.tar.bz2"

SRC_URI[cortexm-toolchain.sha256sum] = "97dbb4f019ad1650b732faffcc881689cedc14e2b7ee863d390e0a41ef16c9a3"
