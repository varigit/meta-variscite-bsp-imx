
# Additional packages we want to add to the host SDK
RDEPENDS:${PN}:append = " \
    nativesdk-uuu \
"
