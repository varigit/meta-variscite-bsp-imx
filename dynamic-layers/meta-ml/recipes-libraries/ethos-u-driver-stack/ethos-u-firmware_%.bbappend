ETHOS_U_FIRMWARE_SRC = "git://github.com/varigit/ethos-u-firmware.git;protocol=https"
SRCBRANCH = "lf-5.15.71_2.2.0_var01"
SRCREV = "4bf517a8000802b394aad90d04dac6b597a612eb"
