SRC_URI:var-som = "git://github.com/varigit/imx-sm;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH:var-som = "lf-6.12.49-2.2.0_var01"
SRCREV:var-som = "491e846f5b18a4d9590b01b72dac121a19efa27f"

COMPATIBLE_MACHINE = "(mx95-generic-bsp)"
