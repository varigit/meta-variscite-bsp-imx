SRC_URI:var-som = "git://github.com/varigit/imx-sm;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH:var-som = "lf-6.12.20-2.0.0_var01"
SRCREV:var-som = "24f30a40fa4805d078b3977864f4e6eaf6865122"

COMPATIBLE_MACHINE = "(mx95-generic-bsp)"
