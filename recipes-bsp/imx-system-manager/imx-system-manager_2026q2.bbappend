SRC_URI:var-som = "git://github.com/varigit/imx-sm;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH:var-som = "lf-6.18.20-2.0.0_var01"
SRCREV:var-som = "d64248f0d565f313551f35f6cfafbc051eefa72c"

COMPATIBLE_MACHINE = "(mx95-generic-bsp)"
