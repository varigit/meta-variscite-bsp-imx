# Copyright 2020-2023 NXP
# Copyright 2023 Variscite Ltd.

# Provide NXP IW612 Wifi firmware
SRC_URI:var-som = "git://github.com/varigit/imx-firmware.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH:var-som = "lf-6.1.36_2.1.0-var01"
SRCREV:var-som = "f0d834846d0d6339a73a97e7816f68b41f345b96"
