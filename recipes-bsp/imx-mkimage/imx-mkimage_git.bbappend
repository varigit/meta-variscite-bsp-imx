# Copyright (C) 2016 Freescale Semiconductor
# Copyright 2017-2021 NXP

require imx-mkimage_git.inc
