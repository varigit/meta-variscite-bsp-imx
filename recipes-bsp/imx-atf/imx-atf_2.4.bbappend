SRC_URI = "git://github.com/varigit/imx-atf;protocol=git;branch=${SRCBRANCH}"
SRCBRANCH = "lf_v2.4_var04"
SRCREV = "e62b30c59f9cf78c6dd3a1f47c2827b2a281e9c0"

SRC_URI_imx8mp-var-dart = "git://github.com/varigit/imx-atf;protocol=git;branch=${SRCBRANCH}"
SRCBRANCH_imx8mp-var-dart = "lf_v2.4_var02"
SRCREV_imx8mp-var-dart = "f9c1b477cf2106b26fc688d8900f09045c2f5a84"
